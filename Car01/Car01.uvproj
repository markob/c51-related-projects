# Keil uVision project Car01.uvproj, settings and files
target at89c2051 (MCS-51)
  device: AT89C2051 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0x7FF) CLOCK(24000000)
  output: Car01 +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: STARTUP.A51 uart.c uart.h types.h main.c pwm.c pwm.h pwm_config.h servo.c servo.h servo_config.h

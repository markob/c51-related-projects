# Keil uVision project MouseSensorReader.uvproj, settings and files
target AT89S8252 (MCS-51)
  device: AT89S8252 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000) MODA2
  output: MouseSensorReader
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: STARTUP.A51 mouse.c types.h OptiMouse.c OptiMouse.h ADNS2610_DRV.h
